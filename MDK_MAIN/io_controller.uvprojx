# Keil uVision project io_controller.uvprojx, settings and files
target X_BOT_APP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_main +hex
  BeforeMake: version.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,X_BOT_MAIN_APP
  c include: ..\cfg;..\csp\stm32f103\LIB;..\csp\stm32f103\LIB\inc;..\csp\stm32f103\System\include;..\csp\stm32f103\usb;..\x_frame\inc;..\bsp\stm32f103;..\bsp\stm32f103\usb;..\app;..\driver\nrf24l01;..\MDK_MAIN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\x_frame\sys_section_flash.sct
  group app
    ../app/: app_main.c math_lib.c protocol_x_bot.c protocol_sbus.c app_link_entity.c
  group cfg
    ../cfg/x_bot_main_app_cfg/: app_cfg.h app_driver_cfg.h app_def_param.h protocol_cmd_cfg.h public_define.h
    ./: version.h
  group frame
    ../x_frame/src/: auto_reg_module.c csm.c debug.c hal_app_interface.c hal_core.c kfifo.c main.c protocol_hal.c linebuf.c shell.c tasks.c ucprobe_action.c kfifo2.c
  group driver
    ../driver/: uart_driver.c systick_driver.c iwdg_driver.c gpio_driver.c pwm_driver.c rtt_driver.c random_driver.c nrf24l01_driver.c usb_driver.c can_driver.c
  group nrf24l01
    ../driver/nrf24l01/: drv_delay.c drv_RF24L01.c drv_spi.c
  group bsp
    ../bsp/stm32f103/: bsp_uart.c bsp_systick.c bsp_iwdg.c bsp_pwm.c bsp_gpio.c SEGGER_RTT.c bsp_adc.c bsp_can.c
  group bsp/usb
    ../bsp/stm32f103/usb/: hw_config.c Queue.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group csp
    ../csp/stm32f103/System/include/: stm32f10x.h system_stm32f10x.h core_cm3.c
    ../csp/stm32f103/System/source/: system_stm32f10x.c
    ../csp/stm32f103/System/source/arm/: startup_stm32f10x_hd_os.s
    ../csp/stm32f103/LIB/: stm32f10x_conf.h
    ../csp/stm32f103/LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group csp/usb
    ../csp/stm32f103/usb/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
